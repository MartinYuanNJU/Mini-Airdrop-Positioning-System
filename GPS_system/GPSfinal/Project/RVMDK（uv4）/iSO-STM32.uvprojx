# Keil uVision project iSO-STM32.uvprojx, settings and files
target 显示英文 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Lcd;..\..\User\delay;..\..\User\ESP8266;..\..\User\GPS;..\..\User\KEY;..\..\User\LED;..\..\User\sys;..\..\User\USART1;..\..\User\USART2;..\..\User\USART3;..\..\User\UART4;..\..\User\usart;..\..\User\SIM900A;..\..\Libraries\FWlib\src;..\..\User\TEMP;D:\study\MDK5\ARM\ARMCC\include;D:\study\MDK5\ARM\ARMCC\lib;..\..\..\GSMfinal\User\SIM900A
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h App.c
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/lcd/: bsp_xpt2046_lcd.c bsp_lcd.c
    ../../User/GPS/: gps.c
    ../../User/KEY/: key.c
    ../../User/LED/: led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/UART4/: uart4.c
    ../../User/USART1/: usart1.c
    ../../User/USART2/: usart2.c
    ../../User/USART3/: usart3.c
    ../../User/sys/: sys.c
    ../../User/delay/: delay.c
    ../../User/TEMP/: temp.c
    ../../../GSMfinal/User/SIM900A/: sim900a.c sim900a.h
software components: CMSIS:CORE 4.1.0
